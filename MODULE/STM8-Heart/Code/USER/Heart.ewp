# IAR project Heart.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..\FWLIB\inc; ..\USERLIB\inc; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Heart.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group FWLIB
    ../FWLIB/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_irtim.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_wfe.c
  group USER
    ./: main.c stm8l15x_it.c
  group USERLIB
    ./: global.c
    ../USERLIB/src/: key.c ld_tasks.c led.c
