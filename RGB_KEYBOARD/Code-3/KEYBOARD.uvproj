# Keil uVision project KEYBOARD.uvproj, settings and files
target PROJ (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: KEYBOARD +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Code\Public
  group SRC
    ./Code/Public/: Debug.C
    ./Code/: main.c usbcfg.c func.c rgb.c hsv2rgb.c
