# Keil uVision project Car.uvprojx, settings and files
target Car (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Car +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F103x8
  c include: ..\FWLIB\inc;..\USERLIB\inc;..\STARTUP;..\MAIN
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Startup
    ../STARTUP/: core_cm3.c startup_stm32f103xb.s
    ../MAIN/: system_stm32f10x.c
  group UserLib
    ../USERLIB/src/: GPIO.c SYS.c usart.c Bluetooth.c ADC.c TIM.c lm393.c
  group MAIN
    ../MAIN/: stm32f10x_it.c main.c global.h global.c
  group Readme
    ../README/: BUG_Report.txt History.txt
